MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "d0f967de013ecc810350e51d07af4064d99a7492"
