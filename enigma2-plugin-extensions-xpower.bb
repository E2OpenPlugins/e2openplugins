MODULE = "XPower"
DESCRIPTION = "remote PC power management for win and linux"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "3a1e16483589cf4a3a7ae09e8000876a41de66c5"
