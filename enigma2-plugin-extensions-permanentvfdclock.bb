MODULE = "PermanentVfdClock"
DESCRIPTION = "Show clock in VFD permanently"

PR="r0"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "a8c5b8ba909b8c28124e92fc2ef47186dbd9a37f"
