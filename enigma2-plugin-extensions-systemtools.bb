MODULE = "SystemTools"
DESCRIPTION = "System Tools for enigma2 stb"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "6008851f1d4556b213fbafaee7340eb9ed19cc6a"
