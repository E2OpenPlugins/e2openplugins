MODULE = "WakeOnLan"
DESCRIPTION = "Send a WOL packet to devices"

require openplugins-distutils.inc

