MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "82111877f0bb5487983e9449757b2d09e5fbdcc4"
