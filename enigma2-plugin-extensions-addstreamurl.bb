MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "99b945be8bb370dccfcb3cde964483c5543f0152"
PR="r0"
