MODULE = "AutoBackup"
DESCRIPTION = "Backup settings automatically"

require openplugins-replace-pli.inc

require openplugins-distutils.inc
