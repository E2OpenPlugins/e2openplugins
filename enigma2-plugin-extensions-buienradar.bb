MODULE = "Buienradar"
DESCRIPTION = "Buienradar actuele situatie"

require openplugins-replace-pli.inc

require openplugins-distutils.inc
