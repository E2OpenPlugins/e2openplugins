MODULE = "ClearMem"
DESCRIPTION = "periodicaly clearing the memory"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
