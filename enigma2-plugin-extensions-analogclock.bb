MODULE = "AnalogClock"

DESCRIPTION = "permanent analog clock on the screen"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "489e80723bb9bd9685bd244ab3f7c9eef05bd279"
