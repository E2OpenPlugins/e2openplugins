MODULE = "TelekomSport"

DESCRIPTION = "Telekom Sport Plugin"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc
