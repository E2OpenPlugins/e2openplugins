MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

require openplugins-replace-pli.inc

require openplugins-distutils.inc

require assume-gplv2.inc

SRCREV = "ce92623bbf93a1ab4c5971fc0e86257e6c2929f8"
